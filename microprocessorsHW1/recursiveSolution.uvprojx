# Keil uVision project recursiveSolution.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: recursiveSolution
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM0\ARMCM0_ac6.sct
  group Source Group 1
    ./: recursive.s
software components: CMSIS:CORE 6.1.0, Device:Startup 2.2.0
